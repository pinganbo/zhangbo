# Keil uVision project YIN_Test.uvprojx, settings and files
target YIN_Test (6140000::V6.14::ARMCLANG)
  device: STM32F410RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: YIN_Test
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=4
  c define: USE_HAL_DRIVER,STM32F410Rx,ARM_MATH_ROUNDING
  c include: ../Core/Inc;                  ../Drivers/STM32F4xx_HAL_Driver/Inc;                  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                  ../Middlewares/Third_Party/FreeRTOS/Source/include;                  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                  ../Drivers/CMSIS/Include;                  ..\Middlewares\Third_Party\YIN;                  ..\Middlewares\Third_Party\kalman_filter;                  ..\Middlewares\Third_Party\MultiButton;                 ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f410rx.s
  group Application/Core/Inc
    ../Core/Inc/: adc.h dma.h FreeRTOSConfig.h gpio.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h tim.h usart.h USER_audio_processing.h Debug_printf.h USER_database.h USER_app_core.h BSP_UI.h
  group Application/User/Core
    ../Core/Src/: Debug_printf.c USER_audio_processing.c USER_database.c USER_app_core.c BSP_UI.c main.c gpio.c adc.c dma.c freertos.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Middlewares/YIN
    ../Middlewares/Third_Party/YIN/: Yin.c Yin.h
  group Middlewares/kalman_filter
    ../Middlewares/Third_Party/kalman_filter/: kalman_filter.c kalman_filter.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/MultiButton
    ../Middlewares/Third_Party/MultiButton/: multi_button.c multi_button.h
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0
